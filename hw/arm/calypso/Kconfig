## hw/arm/calypso/Kconfig
```kconfig
config CALYPSO
    bool
    default y
    depends on TCG && ARM
    select PFLASH_CFI01
    select SERIAL
    select UNIMP
```
